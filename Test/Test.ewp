# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\Drivers\STM32F3xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkIcfFile: C:\Users\fy\Documents\Inbyggda_VT19\Egna_projekt\Pingpong\EWARM\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Pingpong (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  group Application/EWARM
    ../EWARM/: startup_stm32f303xc.s
  group Application/User
    ../Src/: clockinit.c gpio.c i2c.c Pingpong_function.c spi.c stm32f3xx_hal_msp.c stm32f3xx_it.c usb.c
    ./: main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
